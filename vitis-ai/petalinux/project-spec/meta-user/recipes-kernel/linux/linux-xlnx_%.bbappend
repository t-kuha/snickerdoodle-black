SRC_URI += "file://user_2021-10-03-07-45-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

