SRC_URI += "file://user_2019-08-24-15-16-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

