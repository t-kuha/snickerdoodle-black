SRC_URI += "file://user_2020-09-24-16-03-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

