SRC_URI += "file://user_2019-02-12-00-43-00.cfg \
            file://user_2019-08-04-20-56-00.cfg \
            file://user_2019-08-04-22-03-00.cfg \
            file://user_2019-08-04-22-36-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

