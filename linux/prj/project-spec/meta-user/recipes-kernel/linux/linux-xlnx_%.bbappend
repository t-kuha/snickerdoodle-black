SRC_URI += "file://user_2019-02-12-00-43-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

