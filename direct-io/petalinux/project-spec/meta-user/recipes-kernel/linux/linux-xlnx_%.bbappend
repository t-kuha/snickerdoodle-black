SRC_URI += "file://user_2020-09-24-02-54-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

