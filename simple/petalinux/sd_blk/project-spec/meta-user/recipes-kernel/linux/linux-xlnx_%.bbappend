SRC_URI += "file://user_2019-03-03-10-55-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

