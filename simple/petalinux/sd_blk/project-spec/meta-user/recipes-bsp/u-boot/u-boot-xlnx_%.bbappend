FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://platform-top.h \
            file://user_2019-03-03-10-58-00.cfg \
            file://user_2019-03-03-12-00-00.cfg \
            file://user_2019-03-03-12-08-00.cfg \
            "
