SRC_URI += "file://user_2020-04-17-10-47-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

